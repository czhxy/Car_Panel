# Keil uVision project boot.uvprojx, settings and files
target stm32f429 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: boot +hex
  AfterMake: fromelf --bin --output boot.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,BOOTLOADER
  c include: ..\app;..\driver;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\bootloader
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\bootloader.sct
  group boot
    ../bootloader/: boot_main.c
  group bootloader
    ../bootloader/: boot_config.h boot_decision.c boot_decision.h boot_jump.c boot_jump.h flash_control.c flash_control.h key.c key.h ota.c ota.h ota_params.c ota_params.h ymodem.c ymodem.h
  group driver
    ../driver/: Delay.c Delay.h usart.c usart.h
  group firmware/cmsis
    ../firmware/cmsis/device/: startup_stm32f429_439xx.s system_stm32f4xx.c stm32f4xx_it.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_flash.c stm32f4xx_pwr.c stm32f4xx_usart.c
