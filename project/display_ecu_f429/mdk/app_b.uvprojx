# Keil uVision project app_b.uvprojx, settings and files
target stm32f429_b (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08080000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: app_b +hex
  AfterMake: fromelf --bin --output app_b.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,APP_SLOT_B
  c include: ..\app;..\driver;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\components;..\third_lib\FreeRTOS;..\third_lib\FreeRTOS\inc;..\task;..\protocol;..\bootloader
  library: MicroLIB
  memory RVCT4: ROM 0x8080000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app_b.sct
  group startup
    ../firmware/cmsis/device/: startup_stm32f429_439xx.s stm32f4xx_it_asm.s stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
  group app
    ../app/: main.c main.h
  group bsp
    ../app/: bsp_led.c bsp_led.h bsp_log.h bsp_can.c bsp_can.h bsp_key.c bsp_key.h bsp_spi_lcd.c bsp_i2c_touch.c
  group task
    ../task/: mod_comm_can.c mod_comm_can.h task_entry.c task_query.c task_query.h task_comm_can_protocol.c task_comm_can_protocol.h mod_gui.c mod_test.c task_lcd_demo.c
  group driver
    ../driver/: Delay.c Delay.h usart.c usart.h mod_motor.c mod_motor.h
  group protocol
    ../protocol/: can_protocol.h
  group components
    ../components/: my_queue.c my_queue.h
  group FreeRTOS
    ../third_lib/FreeRTOS/src/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
    ../third_lib/FreeRTOS/inc/: FreeRTOS.h FreeRTOSConfig.h
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_flash.c stm32f4xx_pwr.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_spi.c stm32f4xx_i2c.c
