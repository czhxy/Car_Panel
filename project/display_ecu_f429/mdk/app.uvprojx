# Keil uVision project app.uvprojx, settings and files
target stm32f429 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08020000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: app +hex
  AfterMake: fromelf --bin --output app.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,LV_LVGL_H_INCLUDE_SIMPLE,LV_CONF_INCLUDE_SIMPLE
  c include: ..\app;..\driver;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\components;..\third_lib\FreeRTOS;..\third_lib\FreeRTOS\inc;..\task;..\mod;..\protocol;..\bootloader;..\pic;..\third_lib\LVGL\lvgl;..\third_lib\LVGL\lvgl\examples\porting;..\mod
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  group startup
    ../firmware/cmsis/device/: startup_stm32f429_439xx.s stm32f4xx_it_asm.s stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
  group app
    ../app/: main.c main.h
  group bsp
    ../app/: bsp_led.c bsp_led.h bsp_log.h bsp_can.c bsp_can.h bsp_key.c bsp_key.h bsp_spi_lcd.c bsp_i2c_touch.c
  group mod
    ../mod/: mod_can_protocol.c mod_can_protocol.h mod_comm_can.c mod_comm_can.h mod_comm_uart.c mod_comm_uart.h mod_lcd.c mod_lcd.h mod_motor.c mod_motor.h mod_query.c mod_query.h mod_test.c mod_test.h mod_test_pic.h mod_ui.c mod_ui.h
  group task
    ../task/: task_entry.c task_ui.c task_ui.h task_vofa.c task_vofa.h task_comm_can.c task_comm_can.h task_comm_uart.c task_comm_uart.h
  group pic
    ../pic/: dashboard_images.c dashboard_images.h
  group driver
    ../driver/: Delay.c Delay.h usart.c usart.h usart6.c usart6.h
  group protocol
    ../protocol/: can_protocol.h
  group components
    ../components/: my_queue.c my_queue.h
  group FreeRTOS
    ../third_lib/FreeRTOS/src/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
    ../third_lib/FreeRTOS/inc/: FreeRTOS.h FreeRTOSConfig.h
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_flash.c stm32f4xx_pwr.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_spi.c stm32f4xx_i2c.c
  group lvgl_core
    ../third_lib/LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl_draw
    ../third_lib/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../third_lib/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../third_lib/LVGL/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group lvgl_extra
    ../third_lib/LVGL/lvgl/src/extra/: lv_extra.c
    ../third_lib/LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../third_lib/LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../third_lib/LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../third_lib/LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../third_lib/LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../third_lib/LVGL/lvgl/src/extra/widgets/win/: lv_win.c
  group lvgl_font
    ../third_lib/LVGL/lvgl/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_14.c lv_font_montserrat_28.c
  group lvgl_hal
    ../third_lib/LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl_misc
    ../third_lib/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl_widgets
    ../third_lib/LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl_porting
    ../third_lib/LVGL/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
  group lvgl_config
    ../third_lib/LVGL/lvgl/: lv_conf.h lvgl.h
  group lvgl_demo_widgets
    ../third_lib/LVGL/lvgl/demos/widgets/: lv_demo_widgets.c
    ../third_lib/LVGL/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
target stm32f429_b (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08080000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: app_b +hex
  AfterMake: fromelf --bin --output app_b.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,APP_SLOT_B,LV_LVGL_H_INCLUDE_SIMPLE,LV_CONF_INCLUDE_SIMPLE
  c include: ..\app;..\driver;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\components;..\third_lib\FreeRTOS;..\third_lib\FreeRTOS\inc;..\task;..\mod;..\protocol;..\bootloader;..\pic;..\third_lib\LVGL\lvgl;..\third_lib\LVGL\lvgl\examples\porting
  library: MicroLIB
  memory RVCT4: ROM 0x8080000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app_b.sct
